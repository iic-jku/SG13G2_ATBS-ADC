** sch_path: SG13G2_ATBS-ADC-main/cace/templates/amplifier_core_simplified_tb_noise.sch
**.subckt amplifier_core_simplified_tb_noise
E1 vout GND voutp voutn 1
x1 voutp voutn amp_core_en vinn1 vinp1 VDD GND Vcm amplifier_core_simplified
C1 voutp GND CACE{cload} m=1
C2 voutn GND CACE{cload} m=1
VDD VDD GND CACE{vdd}
V1 amp_core_en GND 1.5
VSS VSS GND 0
Vcm Vcm GND CACE{vcm}
E4 Vcm vinn1 net1 GND 0.5
E5 vinp1 Vcm net1 GND 0.5
E6 net1 GND vind GND 1
vin vind GND dc 0 ac 1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.options savecurrents method=gear reltol=1e-2 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.control

* optran 0 0 0 1u 1m 0

save all

set num_threads=1
set enable_noisy_r

* Noise Analysis
noise v(vout) vin dec 101 0.15 512

* Measurements
setplot noise2

* Convert to uVrms
let input_noise_total = inoise_total * 1e6
let output_noise_total = onoise_total * 1e6

echo $&input_noise_total $&output_noise_total > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
