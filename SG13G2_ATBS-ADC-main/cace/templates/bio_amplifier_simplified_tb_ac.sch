** sch_path: SG13G2_ATBS-ADC-main/cace/templates/bio_amplifier_simplified_tb_ac.sch
**.subckt bio_amplifier_simplified_tb_ac
VDD VDD GND CACE{vdd}
C1 voutn1 GND CACE{cload} m=1
C2 voutp1 GND CACE{cload} m=1
E4 Vcm1 vinn1 net1 GND 0.5
E5 vinp1 Vcm1 net1 GND 0.5
E6 net1 GND vind GND 1
V1 bio_amp_en GND 1.5
E1 vout1 GND voutp1 voutn1 1
vin vind GND dc 0 ac 1
VSS VSS GND 0
x1 voutp1 bio_amp_en vinp1 Vcm1 voutn1 vinn1 VDD GND bio_amplifier_simplified_CACE
Vcm1 Vcm1 GND CACE{vcm}
Vcm2 Vcm2 GND CACE{vcm}
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.options savecurrents method=gear reltol=1e-2 abstol=1e-15 gmin=1e-15 rshunt=1e12 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.control

optran 0 0 0 1u 1m 0

* save all
save v(vind) v(vout1)
*save v(vind) v(vout1) v(vout2)

set num_threads=1

* AC Analysis
ac dec 101 0.01 100Meg

* Closed-loop gain
let Acl=v(vout1)/v(vind)
let Acl_dB = vdb(Acl)

* Common-mode gain
*let Acm=v(vout2)/v(vind)
*let Acm_dB = vdb(Acm)

* Common Mode Rejection Ratio (CMRR)
* let CMRR = v(vout1)/v(vout2)
* let CMRR = v(Acl)/v(Acm)
* let CMRR_dB = vdb(CMRR)
* let CMRR_dB = Acl_dB - Acm_dB

* Measurements
* 10Hz closed-loop gain
meas ac Adc_cl_dB find Acl_dB when frequency = 10

* 10Hz CMRR
*meas ac CMRR_dc_dB find CMRR_dB when frequency = 10
let CMRR_dc_dB = 77.66

echo $&Adc_cl_dB $&CMRR_dc_dB > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
