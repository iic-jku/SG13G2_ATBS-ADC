** sch_path: SG13G2_ATBS-ADC-main/cace/templates/vcm_generator_tb_tran.sch
**.subckt vcm_generator_tb_tran
VDD VDD GND CACE{vdd}
V1 phi_1 GND pulse(0 1.5 0 10p 10p {0.5/fphi - 1/fclk} {1/fphi})
V2 phi_2 GND pulse(0 1.5 {0.50/fphi} 10p 10p {0.5/fphi - 1/fclk} {1/fphi})
C9 Vcm GND CACE{cload} m=1
VSS VSS GND 0
x1 VDD phi_2 phi_1 Vcm GND vcm_generator_CACE
**** begin user architecture code

.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ



.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.param fclk=8000000
.param fphi=65200
.param C_VCM=1p
.param W_P=1.0u
.param L_P=0.13u
.param W_N=1.0u
.param L_N=0.13u
.ic v(Vcm)=0
.option savecurrents SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.control

save all

set num_threads=1

* User Constants
let tstep = 500n
let tstart = 0.5m
let tstop = 1m

* Transient Analysis
tran $&tstep $&tstop

* Measurements
meas tran Vcm_at_tstop FIND v(Vcm) at=tstop

* tsettle at 99% Vcm
meas tran tsettle WHEN v(Vcm)=0.7425 RISE=1

echo $&Vcm_at_tstop $&tsettle > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc

**** end user architecture code
**.ends

* expanding   symbol:  vcm_generator_CACE.sym # of pins=5
** sym_path: SG13G2_ATBS-ADC-main/xschem/vcm_generator/vcm_generator_CACE.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/vcm_generator/vcm_generator_CACE.sch
.subckt vcm_generator_CACE VDD di_phi_2 di_phi_1 Vcm VSS
*.iopin VDD
*.opin Vcm
*.iopin VSS
*.ipin di_phi_1
*.ipin di_phi_2
x1 VDD di_phi_2 VSS net1 VDD di_phi_2_n transmission_gate_lv_wo_dummy W_P=1.0u L_P=0.13u W_N=1.0u
+ L_N=0.13u
x2 VDD di_phi_1 VSS Vcm net1 di_phi_1_n transmission_gate_lv_wo_dummy W_P=1.0u L_P=0.13u W_N=1.0u
+ L_N=0.13u
x3 VDD di_phi_2 VSS net3 net2 di_phi_2_n transmission_gate_lv_wo_dummy W_P=1.0u L_P=0.13u W_N=1.0u
+ L_N=0.13u
x4 VDD di_phi_1 VSS Vcm net3 di_phi_1_n transmission_gate_lv_wo_dummy W_P=1.0u L_P=0.13u W_N=1.0u
+ L_N=0.13u
x5 VDD di_phi_1 VSS VSS net2 di_phi_1_n transmission_gate_lv_wo_dummy W_P=1.0u L_P=0.13u W_N=1.0u
+ L_N=0.13u
x9 VDD di_phi_1 di_phi_1_n VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u
x8 VDD di_phi_2 di_phi_2_n VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u
C1 net1 net2 1p m=1
C2 net3 VSS 1p m=1
.ends


* expanding   symbol:  transmission_gate/transmission_gate_lv_wo_dummy.sym # of pins=6
** sym_path: SG13G2_ATBS-ADC-main/xschem/transmission_gate/transmission_gate_lv_wo_dummy.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/transmission_gate/transmission_gate_lv_wo_dummy.sch
.subckt transmission_gate_lv_wo_dummy VDD di_tg_ctrl VSS v_b v_a di_tg_ctrl_n  W_P=1.0u L_P=0.13u
+ W_N=1.0u L_N=0.13u
*.iopin v_a
*.iopin v_b
*.iopin VDD
*.iopin VSS
*.ipin di_tg_ctrl
*.ipin di_tg_ctrl_n
XM1 v_a di_tg_ctrl v_b VSS sg13_lv_nmos w=W_N l=L_N ng=1 m=1 mm_ok=1
XM2 v_a di_tg_ctrl_n v_b VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  inverter/inverter_lv.sym # of pins=4
** sym_path: SG13G2_ATBS-ADC-main/xschem/inverter/inverter_lv.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/inverter/inverter_lv.sch
.subckt inverter_lv VDD vin vout VSS  W_P=3.0u L_P=0.13u W_N=1.0u L_N=0.13u
*.ipin vin
*.iopin VDD
*.iopin VSS
*.opin vout
XM1 vout vin VDD VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
XM2 vout vin VSS VSS sg13_lv_nmos w=W_N l=L_N ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
