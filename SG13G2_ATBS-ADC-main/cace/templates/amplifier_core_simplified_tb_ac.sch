** sch_path: SG13G2_ATBS-ADC-main/cace/templates/amplifier_core_simplified_tb_ac.sch
**.subckt amplifier_core_simplified_tb_ac
VDD VDD GND CACE{vdd}
C1 voutp1 GND CACE{cload} m=1
C2 voutn1 GND CACE{cload} m=1
E4 Vcm1 vinn1 net1 GND 0.5
E5 vinp1 Vcm1 net1 GND 0.5
E6 net1 GND vind GND 1
V1 amp_core_en GND 1.5
E1 vout1 GND voutp1 voutn1 1
vin vind GND dc 0 ac 1
VSS VSS GND 0
x1 voutp1 voutn1 amp_core_en vinn1 vinp1 VDD GND Vcm1 amplifier_core_simplified
C3 voutp2 GND CACE{cload} m=1
C4 voutn2 GND CACE{cload} m=1
E2 Vcm2 vinn2 net2 GND -0.5
E3 vinp2 Vcm2 net2 GND 0.5
E7 net2 GND vind GND 1
x2 voutp2 voutn2 amp_core_en vinn2 vinp2 VDD GND Vcm2 amplifier_core_simplified
E8 vout2 GND voutp2 net3 0.5
E10 net3 GND voutn2 GND -1
Vcm1 Vcm1 GND CACE{vcm}
C5 voutp3 GND CACE{cload} m=1
C6 voutn3 GND CACE{cload} m=1
x4 voutp4 voutn4 amp_core_en net5 net6 VDD GND Vcm4 amplifier_core_simplified
x5 voutp5 voutn5 amp_core_en net7 net7 VDD GND Vcm5 amplifier_core_simplified
vin_dm vin_dm Vcm dc 0 ac 1
E11 net4 GND vin_dm GND -1
vin_cm vin_cm Vcm dc 0 ac 1
Vmeasp vin_dm net6 0
.save i(vmeasp)
Vmeasn net4 net5 0
.save i(vmeasn)
Vmeas_cm vin_cm net7 0
.save i(vmeas_cm)
C7 voutp4 GND CACE{cload} m=1
C8 voutn4 GND CACE{cload} m=1
C9 voutp5 GND CACE{cload} m=1
C10 voutn5 GND CACE{cload} m=1
x3 voutp3 voutn3 amp_core_en Vcm3 Vcm3 vdd_noise GND Vcm3 amplifier_core_simplified
E9 vout3 GND voutp3 voutn3 1
Vnoise vdd_noise net8 dc 0 ac 1
V2 net8 GND CACE{vdd}
Vcm2 Vcm2 GND CACE{vcm}
Vcm3 Vcm3 GND CACE{vcm}
Vcm4 Vcm4 GND CACE{vcm}
Vcm5 Vcm5 GND CACE{vcm}
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.options savecurrents method=gear reltol=1e-2 abstol=1e-15 gmin=1e-15 rshunt=1e12 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.control

* optran 0 0 0 1u 1m 0

* save all
save v(vind) v(vout1) v(vout2) v(vout3) v(vdd_noise) v(vin_dm) v(vin_cm)

set num_threads=1

* AC Analysis
ac dec 101 0.01 100Meg

* Open-loop gain
let Aol=v(vout1)/v(vind)
let Aol_dB = vdb(Aol)

* Common-mode gain
let Acm=v(vout2)/v(vind)
let Acm_dB = vdb(Acm)

* Common Mode Rejection Ratio (CMRR)
* let CMRR = v(vout1)/v(vout2)
let CMRR = v(Aol)/v(Acm)
let CMRR_dB = vdb(CMRR)
* let CMRR_dB = Aol_dB - Acm_dB

* PSRR
let PSRR = v(vdd_noise)/v(vout3)
let PSRR_dB = vdb(PSRR)

* Differential Mode Zin
let Zin_dm = v(vin_dm) / (i(Vmeasp) - i(Vmeasn))

* Common Mode Zin
let Zin_cm = v(vin_cm) / i(Vmeas_cm)

* Measurements
* 10Hz open-loop gain
meas ac Adc_ol_dB find Aol_dB when frequency = 10

* 3dB cut-off frequency
let Aol_3dB = Adc_ol_dB - 3
meas ac fc WHEN Aol_dB=Aol_3dB FALL=1

* Unity Gain Bandwidth (Aol=1 or Aol_dB=0dB)
meas ac UGB when Aol_dB=0 fall=1

* Phase Margin at Aol=1 or Aol_dB=0dB
let Aol_arg = 180/PI*cphase(Aol)
meas ac arg_0dB find Aol_arg when Aol_dB=0
let PM = 180-abs(arg_0dB)

* 10Hz CMRR
meas ac CMRR_dc_dB find CMRR_dB when frequency = 10

* 10Hz PSRR
meas ac PSRR_dc_dB find PSRR_dB when frequency = 10

* 10Hz differential input impedance
meas ac Zin_dc_dm find Zin_dm when frequency = 10

* 10Hz common-mode input impedance
meas ac Zin_dc_cm find Zin_cm when frequency = 10

* echo $&Adc_ol_dB $&fc $&UGB $&PM $&CMRR_dc_dB $&PSRR_dc_dB $&Zin_dc_dm $&Zin_dc_cm > CACE{simpath}/CACE{filename}_CACE{N}.data
echo $&Adc_ol_dB $&fc $&UGB $&PM $&CMRR_dc_dB $&Zin_dc_dm $&Zin_dc_cm > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
