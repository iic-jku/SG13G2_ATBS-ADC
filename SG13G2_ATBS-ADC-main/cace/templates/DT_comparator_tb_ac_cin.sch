** sch_path: SG13G2_ATBS-ADC-main/cace/templates/DT_comparator_tb_ac_cin.sch
**.subckt DT_comparator_tb_ac_cin
VDD VDD GND CACE{vdd}
V1 clk GND CACE{vdd}
V2 clk_n GND 0
Vmeasp vin net1 0
.save i(vmeasp)
Vmeasn net4 net3 0
.save i(vmeasn)
vin vin net2 dc 0 ac 1
Vcm net2 GND CACE{vcm}
E2 net4 GND vin GND -1
C2 vout GND CACE{cload} m=1
x1 VDD net1 vout net3 clk GND DT_comparator
**** begin user architecture code

.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ



.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.options savecurrents reltol=1e-3 abstol=1e-12 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.control
save all

set num_threads=1

* User Constants
let fstart = 1
let fstop = 1G

* AC Analysis
ac dec 101 $&fstart $&fstop

* Plotting Cinp
let Cinp = mag(i(Vmeasp)) / (2 * 3.14 * frequency)

* Plotting Cinn
let Cinn = mag(i(Vmeasn)) / (2 * 3.14 * frequency)

* Measure avg. Cinp & Cinn
meas ac Cinp_avg AVG Cinp from=fstart to=fstop
meas ac Cinn_avg AVG Cinn from=fstart to=fstop

echo $&Cinp_avg $&Cinn_avg > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc

**** end user architecture code
**.ends

* expanding   symbol:  DT_comparator.sym # of pins=6
** sym_path: SG13G2_ATBS-ADC-main/xschem/comparator/discrete_time/DT_comparator.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/comparator/discrete_time/DT_comparator.sch
.subckt DT_comparator VDD vinp vout vinn di_clk VSS
*.iopin VDD
*.opin vout
*.iopin VSS
*.ipin vinp
*.ipin vinn
*.ipin di_clk
x2 VDD voutp_comp voutp_buf VSS buffer_lv W_P_INV=1.0u L_P_INV=0.13u W_N_INV=1.0u L_N_INV=0.13u
x3 VDD voutn_comp voutn_buf VSS buffer_lv W_P_INV=1.0u L_P_INV=0.13u W_N_INV=1.0u L_N_INV=0.13u
x5 VDD di_clk net1 VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u
* noconn #net2
x4 VDD voutp_buf net2 VSS vout voutn_buf SR_latch W_P_SR=1.0u L_P_SR=0.13u W_N_SR=1.0u L_N_SR=0.13u
x1 net1 di_clk VDD voutp_comp vinp VSS voutn_comp vinn dynamic_biasing_comparator
.ends


* expanding   symbol:  buffer/buffer_lv.sym # of pins=4
** sym_path: SG13G2_ATBS-ADC-main/xschem/buffer/buffer_lv.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/buffer/buffer_lv.sch
.subckt buffer_lv VDD vin vout VSS  W_P_INV=3.0u L_P_INV=0.13u W_N_INV=1.0u L_N_INV=0.13u
*.ipin vin
*.iopin VDD
*.iopin VSS
*.opin vout
x1 VDD vin net1 VSS inverter_lv W_P=W_P_INV L_P=L_P_INV W_N=W_N_INV L_N=L_N_INV
x2 VDD net1 vout VSS inverter_lv W_P=W_P_INV L_P=L_P_INV W_N=W_N_INV L_N=L_N_INV
.ends


* expanding   symbol:  inverter/inverter_lv.sym # of pins=4
** sym_path: SG13G2_ATBS-ADC-main/xschem/inverter/inverter_lv.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/inverter/inverter_lv.sch
.subckt inverter_lv VDD vin vout VSS  W_P=3.0u L_P=0.13u W_N=1.0u L_N=0.13u
*.ipin vin
*.iopin VDD
*.iopin VSS
*.opin vout
XM1 vout vin VDD VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
XM2 vout vin VSS VSS sg13_lv_nmos w=W_N l=L_N ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  comparator/SR_latch/SR_latch.sym # of pins=6
** sym_path: SG13G2_ATBS-ADC-main/xschem/comparator/SR_latch/SR_latch.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/comparator/SR_latch/SR_latch.sch
.subckt SR_latch VDD S Qn VSS Q R  W_P_SR=1.0u L_P_SR=0.13u W_N_SR=1.0u L_N_SR=0.13u
*.iopin VDD
*.opin Q
*.iopin VSS
*.ipin S
*.ipin R
*.opin Qn
x1 VDD Q R Qn VSS NOR_gate W_P=W_P_SR L_P=L_P_SR W_N=W_N_SR L_N=L_N_SR
x2 VDD Qn Q S VSS NOR_gate W_P=W_P_SR L_P=L_P_SR W_N=W_N_SR L_N=L_N_SR
.ends


* expanding   symbol:  comparator/discrete_time/Dynamic-biasing/dynamic_biasing_comparator.sym # of
*+ pins=8
** sym_path: SG13G2_ATBS-ADC-main/xschem/comparator/discrete_time/Dynamic-biasing/dynamic_biasing_comparator.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/comparator/discrete_time/Dynamic-biasing/dynamic_biasing_comparator.sch
.subckt dynamic_biasing_comparator di_clk_n di_clk VDD voutp vinp VSS voutn vinn
*.iopin VDD
*.opin voutp
*.opin voutn
*.ipin di_clk_n
*.iopin VSS
*.ipin vinp
*.ipin vinn
*.ipin di_clk
XM3a vs di_clk vctail VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM12 voutp di_clk_n VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM8 net1 voutn VDD VDD sg13_lv_pmos w=2.0u l=0.13u ng=2 m=1 mm_ok=1
XM10 voutp voutn VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM11 voutn voutp VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM13 voutn di_clk_n VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
CPn vcpn VSS 300f m=1
CPp vcpp VSS 300f m=1
XM9 net2 voutp VDD VDD sg13_lv_pmos w=2.0u l=0.13u ng=2 m=1 mm_ok=1
XM6 voutp vcpn net1 VDD sg13_lv_pmos w=2.0u l=0.13u ng=2 m=1 mm_ok=1
XM7 voutn vcpp net2 VDD sg13_lv_pmos w=2.0u l=0.13u ng=2 m=1 mm_ok=1
CTAIL vctail VSS 600f m=1
XM3b vctail di_clk_n VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM1 vcpn vinp vs VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM2 vcpp vinn vs VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM4 vcpn di_clk VDD VDD sg13_lv_pmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM5 vcpp di_clk VDD VDD sg13_lv_pmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  comparator/NOR_gate/NOR_gate.sym # of pins=5
** sym_path: SG13G2_ATBS-ADC-main/xschem/comparator/NOR_gate/NOR_gate.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/comparator/NOR_gate/NOR_gate.sch
.subckt NOR_gate VDD C A B VSS  W_P=1.0u L_P=0.13u W_N=0.5u L_N=0.13u
*.iopin VDD
*.opin C
*.iopin VSS
*.ipin A
*.ipin B
XM1 C A VSS VSS sg13_lv_nmos w=W_N l=L_N ng=1 m=1 mm_ok=1
XM2 C B VSS VSS sg13_lv_nmos w=W_N l=L_N ng=1 m=1 mm_ok=1
XM3 C B net1 VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
XM4 net1 A VDD VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
XM5 C A net2 VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
XM6 net2 B VDD VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
