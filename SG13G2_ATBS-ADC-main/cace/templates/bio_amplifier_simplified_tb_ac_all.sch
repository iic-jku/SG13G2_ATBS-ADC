** sch_path: SG13G2_ATBS-ADC-main/cace/templates/bio_amplifier_simplified_tb_ac_all.sch
**.subckt bio_amplifier_simplified_tb_ac_all
VDD VDD GND CACE{vdd}
C1 voutn1 GND CACE{cload} m=1
C2 voutp1 GND CACE{cload} m=1
E4 Vcm1 vinn1 net1 GND 0.5
E5 vinp1 Vcm1 net1 GND 0.5
E6 net1 GND vind GND 1
V1 bio_amp_en GND 1.5
E1 vout1 GND voutp1 voutn1 1
vin vind GND dc 0 ac 1
VSS VSS GND 0
C3 voutn2 GND CACE{cload} m=1
C4 voutp2 GND CACE{cload} m=1
E2 Vcm2 vinn2 net2 GND -0.5
E3 vinp2 Vcm2 net2 GND 0.5
E7 net2 GND vind GND 1
E8 vout2 GND voutp2 net3 0.5
E10 net3 GND voutn2 GND -1
C5 voutn3 GND CACE{cload} m=1
C6 voutp3 GND CACE{cload} m=1
vin_dm vin_dm Vcm dc 0 ac 1
E11 net4 GND vin_dm GND -1
vin_cm vin_cm Vcm dc 0 ac 1
Vmeasp vin_dm net6 0
.save i(vmeasp)
Vmeasn net4 net7 0
.save i(vmeasn)
Vmeas_cm vin_cm net5 0
.save i(vmeas_cm)
C7 voutn4 GND CACE{cload} m=1
C8 voutp4 GND CACE{cload} m=1
C9 voutn5 GND CACE{cload} m=1
C10 voutp5 GND CACE{cload} m=1
E9 vout3 GND voutp3 voutn3 1
Vnoise vdd_noise VDD 0 AC 1
x1 voutp1 bio_amp_en vinp1 Vcm1 voutn1 vinn1 VDD GND bio_amplifier_simplified_CACE
x2 voutp2 bio_amp_en vinp2 Vcm2 voutn2 vinn2 VDD GND bio_amplifier_simplified_CACE
x3 voutp3 bio_amp_en Vcm3 Vcm3 voutn3 Vcm3 vdd_noise GND bio_amplifier_simplified_CACE
x4 voutp4 bio_amp_en net6 Vcm4 voutn4 net7 VDD GND bio_amplifier_simplified_CACE
x5 voutp5 bio_amp_en net5 Vcm5 voutn5 net5 VDD GND bio_amplifier_simplified_CACE
Vcm1 Vcm1 GND CACE{vcm}
Vcm2 Vcm2 GND CACE{vcm}
Vcm3 Vcm3 GND CACE{vcm}
Vcm4 Vcm4 GND CACE{vcm}
Vcm5 Vcm5 GND CACE{vcm}
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.options savecurrents method=gear reltol=1e-2 abstol=1e-15 gmin=1e-15 rshunt=1e12 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.control

optran 0 0 0 1u 1m 0

* save all
save v(vind) v(vout1) v(vout2) v(vout3) v(vdd_noise) v(vin_dm) v(vin_cm)

set num_threads=1

* AC Analysis
ac dec 101 0.01 100Meg

* Closed-loop gain
let Acl=v(vout1)/v(vind)
let Acl_dB = vdb(Acl)

* Common-mode gain
let Acm=v(vout2)/v(vind)
let Acm_dB = vdb(Acm)

* Common Mode Rejection Ratio (CMRR)
* let CMRR = v(vout1)/v(vout2)
let CMRR = v(Acl)/v(Acm)
let CMRR_dB = vdb(CMRR)
* let CMRR_dB = Acl_dB - Acm_dB

* PSRR
let PSRR = v(vdd_noise)/v(vout3)
let PSRR_dB = vdb(PSRR)

* Differential Mode Zin
let Zin_dm = v(vin_dm) / (i(Vmeasp) - i(Vmeasn))

* Common Mode Zin
let Zin_cm = v(vin_cm) / i(Vmeas_cm)

* Measurements
* 10Hz closed-loop gain
meas ac Adc_cl_dB find Acl_dB when frequency = 10

* Lower 3dB cut-off frequency
let Amag_fc = Adc_cl_dB-3
meas ac fcl find frequency when Acl_dB = Amag_fc RISE=1

* Upper 3dB cut-off frequency
meas ac fcu find frequency when Acl_dB = Amag_fc FALL=1

* 10Hz CMRR
meas ac CMRR_dc_dB find CMRR_dB when frequency = 10

* 10Hz PSRR
meas ac PSRR_dc_dB find PSRR_dB when frequency = 10

* 10Hz differential input impedance
meas ac Zin_dc_dm find Zin_dm when frequency = 10

* 10Hz common-mode input impedance
meas ac Zin_dc_cm find Zin_cm when frequency = 10

* echo $&Adc_cl_dB $&fcl $&fcu $&CMRR_dc_dB $&PSRR_dc_dB $&Zin_dc_dm $&Zin_dc_cm > CACE{simpath}/CACE{filename}_CACE{N}.data
echo $&Adc_cl_dB $&fcl $&fcu $&CMRR_dc_dB $&Zin_dc_dm $&Zin_dc_cm > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
