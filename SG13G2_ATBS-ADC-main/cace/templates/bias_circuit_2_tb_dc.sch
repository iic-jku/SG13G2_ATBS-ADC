** sch_path: SG13G2_ATBS-ADC-main/cace/templates/bias_circuit_2_tb_dc.sch
**.subckt bias_circuit_2_tb_dc
VDD VDD GND CACE{vdd}
x1 VDD Vbiasc VDD GND Vbias bias_circuit_2
**** begin user architecture code

.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ



.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.options savecurrents reltol=1e-3 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.control

save all

set num_threads=1

* DC Sweep of VDD
let vdd_stop=CACE{vdd} + 0.01
dc VDD 0 $&vdd_stop 5m

* Measurements
let Iout_nominal = 10e-9
let Iout_99_percent = 0.99 * Iout_nominal
print Iout_99_percent
meas dc VDD_min WHEN i(v.x1.viout)=Iout_99_percent

meas dc Iout_1_4V FIND i(v.x1.viout) at=1.4
meas dc Iout_1_3V FIND i(v.x1.viout) at=1.3
let Iout_volt = (Iout_1_4V - Iout_1_3V) * 10
print Iout_volt

meas dc Iout_VDD FIND i(v.x1.viout) at=CACE{vdd}

echo $&Iout_VDD $&Iout_volt > CACE{simpath}/CACE{filename}_CACE{N}.data

*quit
.endc

**** end user architecture code
**.ends

* expanding   symbol:  bias_circuit_2.sym # of pins=5
** sym_path: SG13G2_ATBS-ADC-main/xschem/bio_amplifier/amplifier_core/bias_circuit/bias_circuit_2/bias_circuit_2.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/bio_amplifier/amplifier_core/bias_circuit/bias_circuit_2/bias_circuit_2.sch
.subckt bias_circuit_2 di_bias_en Vbiasc VDD VSS Vbias
*.iopin VDD
*.iopin VSS
*.opin Vbias
*.ipin di_bias_en
*.opin Vbiasc
R1 net3 VSS 3.72Meg m=1
XMDEC1 net1 Vbias net1 net1 sg13_lv_nmos w=100.0u l=40.0u ng=100 m=1 mm_ok=1
VIref net4 net8 0
.save i(viref)
VIout net9 Vbiasc 0
.save i(viout)
x1 VDD di_bias_en bias_en_n VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u
xMSU2 Vsu net6 VSS VSS sg13g2_lv_nmos_stacked_x4 W_N=1.0u L_N=40.0u NG_N=1 M_N=1
xMSU1 net5 Vsu VSS net6 sg13g2_lv_nmos_stacked_x4 W_N=1.0u L_N=40.0u NG_N=1 M_N=1
Vmeas1 net4 net5 0
.save i(vmeas1)
Vmeas2 Vbias net6 0
.save i(vmeas2)
XMPD1 Vgs_m34 di_bias_en net2 net2 sg13_lv_pmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XMPD2 net4 bias_en_n Vgs_m34 net2 sg13_lv_pmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XMPD3 Vbias bias_en_n VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
VIref5 net1 VSS 0
.save i(viref5)
VIdd VDD net2 0
.save i(vidd)
CSU1 net10 Vsu 35f m=1
xM1 net7 Vbias VSS net3 sg13g2_lv_nmos_stacked_x2 W_N=20.0u L_N=20.0u NG_N=20 M_N=1
xM1c net8 Vbiasc VSS net7 sg13g2_lv_nmos_stacked_x2 W_N=5.0u L_N=20.0u NG_N=5 M_N=1
xM2 Vbias Vbias VSS VSS sg13g2_lv_nmos_stacked_x2 W_N=5.0u L_N=20.0u NG_N=5 M_N=1
xM2c Vbiasc Vbiasc VSS Vbias sg13g2_lv_nmos_stacked_x2 W_N=5.0u L_N=20.0u NG_N=5 M_N=1
XMDEC2 net2 Vgs_m34 net2 net2 sg13_lv_pmos w=25.0u l=40.0u ng=25 m=1 mm_ok=1
xM3 net4 Vgs_m34 net2 net2 sg13g2_lv_pmos_stacked_x4 W_P=20.0u L_P=40.0u NG_P=20 M_P=1
xM4 net9 Vgs_m34 net2 net2 sg13g2_lv_pmos_stacked_x4 W_P=20.0u L_P=40.0u NG_P=20 M_P=1
XMPD6 Vsu di_bias_en net10 net10 sg13_lv_pmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XMPD4 Vbiasc bias_en_n VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XMPD7 Vsu bias_en_n VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XMPD5 net10 bias_en_n net2 net2 sg13_lv_pmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  inverter/inverter_lv.sym # of pins=4
** sym_path: SG13G2_ATBS-ADC-main/xschem/inverter/inverter_lv.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/inverter/inverter_lv.sch
.subckt inverter_lv VDD vin vout VSS  W_P=3.0u L_P=0.13u W_N=1.0u L_N=0.13u
*.ipin vin
*.iopin VDD
*.iopin VSS
*.opin vout
XM1 vout vin VDD VDD sg13_lv_pmos w=W_P l=L_P ng=1 m=1 mm_ok=1
XM2 vout vin VSS VSS sg13_lv_nmos w=W_N l=L_N ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  stacked_transistors/sg13g2_lv_nmos_stacked/sg13g2_lv_nmos_stacked_x4.sym # of
*+ pins=4
** sym_path: SG13G2_ATBS-ADC-main/xschem/stacked_transistors/sg13g2_lv_nmos_stacked/sg13g2_lv_nmos_stacked_x4.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/stacked_transistors/sg13g2_lv_nmos_stacked/sg13g2_lv_nmos_stacked_x4.sch
.subckt sg13g2_lv_nmos_stacked_x4 D G B S  W_N=1.0u L_N=0.45u NG_N=1 M_N=1
*.iopin D
*.iopin S
*.iopin G
*.iopin B
XM1 net1 G S B sg13_lv_nmos w=W_N l=L_N/4 ng=NG_N m=M_N mm_ok=1
XM2 net3 G net1 B sg13_lv_nmos w=W_N l=L_N/4 ng=NG_N m=M_N mm_ok=1
XM3 net2 G net3 B sg13_lv_nmos w=W_N l=L_N/4 ng=NG_N m=M_N mm_ok=1
XM4 D G net2 B sg13_lv_nmos w=W_N l=L_N/4 ng=NG_N m=M_N mm_ok=1
.ends


* expanding   symbol:  stacked_transistors/sg13g2_lv_nmos_stacked/sg13g2_lv_nmos_stacked_x2.sym # of
*+ pins=4
** sym_path: SG13G2_ATBS-ADC-main/xschem/stacked_transistors/sg13g2_lv_nmos_stacked/sg13g2_lv_nmos_stacked_x2.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/stacked_transistors/sg13g2_lv_nmos_stacked/sg13g2_lv_nmos_stacked_x2.sch
.subckt sg13g2_lv_nmos_stacked_x2 D G B S  W_N=1.0u L_N=0.45u NG_N=1 M_N=1
*.iopin D
*.iopin S
*.iopin G
*.iopin B
XM1 net1 G S B sg13_lv_nmos w=W_N l=L_N/2 ng=NG_N m=M_N mm_ok=1
XM2 D G net1 B sg13_lv_nmos w=W_N l=L_N/2 ng=NG_N m=M_N mm_ok=1
.ends


* expanding   symbol:  stacked_transistors/sg13g2_lv_pmos_stacked/sg13g2_lv_pmos_stacked_x4.sym # of
*+ pins=4
** sym_path: SG13G2_ATBS-ADC-main/xschem/stacked_transistors/sg13g2_lv_pmos_stacked/sg13g2_lv_pmos_stacked_x4.sym
** sch_path: SG13G2_ATBS-ADC-main/xschem/stacked_transistors/sg13g2_lv_pmos_stacked/sg13g2_lv_pmos_stacked_x4.sch
.subckt sg13g2_lv_pmos_stacked_x4 D G B S  W_P=1.0u L_P=0.45u NG_P=1 M_P=1
*.iopin D
*.iopin S
*.iopin G
*.iopin B
XM1 net1 G S B sg13_lv_pmos w=W_P l=L_P/4 ng=NG_P m=M_P mm_ok=1
XM2 net3 G net1 B sg13_lv_pmos w=W_P l=L_P/4 ng=NG_P m=M_P mm_ok=1
XM3 net2 G net3 B sg13_lv_pmos w=W_P l=L_P/4 ng=NG_P m=M_P mm_ok=1
XM4 D G net2 B sg13_lv_pmos w=W_P l=L_P/4 ng=NG_P m=M_P mm_ok=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
